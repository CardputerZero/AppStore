## main/Kconfig
```kconfig
menu "VibAPP"

config VIBAPP_PLACEHOLDER
    bool "Placeholder"
    default y

endmenu
```
